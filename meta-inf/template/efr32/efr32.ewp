# IAR project efr32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: $--partNumber--$; RETARGET_VCOM; CONFIGURATION_HEADER="$--generatedHeader--$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjFs--$/submodules/CMSIS/include; $--stackDirFromProjFs--$/submodules/Device/SiliconLabs/$--chipFamily;U--$/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $--deviceName--$.bin
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkAdditionalLibs: $--stackDirFromProjBs--$\autogen\librail_release\librail_efr32_iar_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $--partNumber--$; RETARGET_VCOM; CONFIGURATION_HEADER="$--generatedHeader--$"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    $--stackDirFromProjFs--$/submodules/Device/SiliconLabs/$--chipFamily;U--$/Source/IAR/: startup_$--chipFamily;L--$.s
    $--stackDirFromProjFs--$/submodules/Device/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
